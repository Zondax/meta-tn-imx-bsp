PLATFORM_FLAVOR_pico-imx8mq = "mx8mqevk"
PLATFORM_FLAVOR_flex-imx8mm = "mx8mmevk"
